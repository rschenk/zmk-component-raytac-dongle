## boards/raytac/mdbt50q_cx_40/Kconfig.mdbt50q_cx_40
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_MDBT50Q_CX_40
	select SOC_NRF52840_QIAA
	select ZMK_BOARD_COMPAT
```
